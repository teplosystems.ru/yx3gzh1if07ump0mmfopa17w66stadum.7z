# Autodesk Inventor part: EV3000-10-110
## iProperties
Created: 2012-06
Part Number: EV3000-10-110
Document SubType Name: Modeling
Designer: Walder
Author: Walder
